# Keil uVision project LudoV1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82F6D17 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0-0x2FF) CLOCK(25000000)
  output: LudoV1.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HardWareCode;..\UserCode
  group HARDWARE
    ../HardWareCode/: HardWare.c SPI.c Timer0.c SystemClock.c Delay.c eeprom.c memmap.c BOD.c
  group USER
    ../UserCode/: MAIN.C Dice.c LedBoard.c UserDriverBridge.c USER.c UserInput.c Buzzer.c Settings.c
